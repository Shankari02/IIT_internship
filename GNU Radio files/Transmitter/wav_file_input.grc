options:
  parameters:
    author: shankari
    generate_options: qt_gui
    id: freq_range_check
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/shankari/test.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/shankari/Downloads/bsdl/music/sa.wav
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy\nfrom gnuradio import gr\nimport serial\n\nclass blk(gr.basic_block):\n    def __init__(self):\n        gr.basic_block.__init__(\n            self,\n            name=\"UART IQ TX (Interleaved)\",\n            in_sig=[numpy.uint8, numpy.uint8],  # I and Q streams\n            out_sig=[]\n        )\n        self.ser = serial.Serial(\n\tport='/dev/ttyUSB1',   # Set your correct UART port\n\tbaudrate=500000,      # 1 Mbps\n\ttimeout = 0.001\n        )\n\n    def __del__(self):\n        if self.ser and self.ser.is_open:\n            self.ser.close()\n\n    def general_work(self, input_items, output_items):\n        I = input_items[0]\n        Q = input_items[1]\n\n        n = min(len(I), len(Q))\n        # Interleave I and Q\n        interleaved = numpy.empty(2 * n, dtype=numpy.uint8)\n        interleaved[0::2] = I[:n]\n        interleaved[1::2] = Q[:n]\n\n        try:\n            self.ser.write(interleaved.tobytes())\n        except Exception as e:\n            print(\"UART Write Error:\", e)\n\n        # Tell GNU Radio we consumed the items\n        self.consume(0, n)\n        self.consume(1, n)\n        return 0  # Let GNU Radio schedule again\n\n"
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '125'
    win: window.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}

connections:
- [blocks_complex_to_float_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_float_to_uchar_0_0, '0']
- [blocks_float_to_uchar_0, '0', epy_block_0, '0']
- [blocks_float_to_uchar_0_0, '0', epy_block_0, '1']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_1, '0', hilbert_fc_0, '0']
- [blocks_wavfile_source_0_0, '0', blocks_throttle_0, '0']
- [blocks_wavfile_source_0_0, '0', blocks_throttle_1, '0']
- [hilbert_fc_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
